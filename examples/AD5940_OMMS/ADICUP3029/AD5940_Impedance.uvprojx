# Keil uVision project AD5940_Impedance.uvprojx, settings and files
target ADICUP3029 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.3.2.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AD5940_Impedance +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHIPSEL_594X
  c include: ..\..\AD5940Lib;..\..;.\ADICUP3029
  asm define: CHIPSEL_594X, __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group AD5940Lib
    ../../AD5940Lib/: ad5940.c
    ./: ADICUP3029Port.c
  group Application
    ./: main.c
    ../: AD5940Main.c Impedance.c SignalGen.c Amperometric.c UARTCmd.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, Device:Global Configuration 3.2.0, Device:Startup 3.2.0
